# IAR project mx25lx_flash_read_write_sam_a5d2_xult.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_a5d2_xult_iar; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult_iar\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar
    ../src/config/sam_a5d2_xult_iar/: device_cache.h toolchain_specifics.h definitions.h device.h user.h configuration.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/qspi
    ../src/config/sam_a5d2_xult_iar/peripheral/qspi/: plib_qspi_common.h plib_qspi0.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/pit
    ../src/config/sam_a5d2_xult_iar/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/mmu
    ../src/config/sam_a5d2_xult_iar/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/matrix
    ../src/config/sam_a5d2_xult_iar/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/l2cc
    ../src/config/sam_a5d2_xult_iar/peripheral/l2cc/: plib_l2cc.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/clk
    ../src/config/sam_a5d2_xult_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/pio
    ../src/config/sam_a5d2_xult_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/peripheral/aic
    ../src/config/sam_a5d2_xult_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/bsp
    ../src/config/sam_a5d2_xult_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/driver
    ../src/config/sam_a5d2_xult_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/driver/mx25l
    ../src/config/sam_a5d2_xult_iar/driver/mx25l/: drv_mx25l.h drv_mx25l_definitions.h
    ../src/config/sam_a5d2_xult_iar/driver/mx25l/src/: drv_mx25l_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system
    ../src/config/sam_a5d2_xult_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/int
    ../src/config/sam_a5d2_xult_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/ports
    ../src/config/sam_a5d2_xult_iar/system/ports/: sys_ports.h sys_ports_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/cache
    ../src/config/sam_a5d2_xult_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/system/debug
    ../src/config/sam_a5d2_xult_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xult_iar/osal
    ../src/config/sam_a5d2_xult_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_cp15.h core_ca.h
  group Harmony3/Source Files
    ../src/: main.c app.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar
    ../src/config/sam_a5d2_xult_iar/: initialization.c interrupts.c cstartup.s fault_handlers.c tasks.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/qspi
    ../src/config/sam_a5d2_xult_iar/peripheral/qspi/: plib_qspi0.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/pit
    ../src/config/sam_a5d2_xult_iar/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/mmu
    ../src/config/sam_a5d2_xult_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/matrix
    ../src/config/sam_a5d2_xult_iar/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/l2cc
    ../src/config/sam_a5d2_xult_iar/peripheral/l2cc/: plib_l2cc.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/clk
    ../src/config/sam_a5d2_xult_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/pio
    ../src/config/sam_a5d2_xult_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/peripheral/aic
    ../src/config/sam_a5d2_xult_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/bsp
    ../src/config/sam_a5d2_xult_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/driver/mx25l
    ../src/config/sam_a5d2_xult_iar/driver/mx25l/src/: drv_mx25l.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/stdio
    ../src/config/sam_a5d2_xult_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/system/int
    ../src/config/sam_a5d2_xult_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_a5d2_xult_iar/system/cache
    ../src/config/sam_a5d2_xult_iar/system/cache/: sys_cache.c
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult_iar/: ddr.icf
