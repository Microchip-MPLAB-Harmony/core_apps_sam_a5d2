# IAR project usart_multi_instance_freertos_sam_a5d2_xult_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCIncludePath2: ..\src; ..\src\config\sam_a5d2_xult_freertos_iar; ..\src\packs\ATSAMA5D27_DFP; ..\src\packs\CMSIS\CMSIS\Core_A\Include; ..\src\packs\CMSIS; ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\src\third_party\rtos\FreeRTOS\Source\include; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\third_party\rtos\FreeRTOS\Source\portable\IAR\SAM\CA5; ..\src\config\sam_a5d2_xult_freertos_iar; .
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xult_freertos.out
  ILINK.IlinkIcfFile: ..\src\config\sam_a5d2_xult_freertos_iar\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app_usart_usb_click_board.h app_usart_usb_debug_port.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar
    ../src/config/sam_a5d2_xult_freertos_iar/: configuration.h definitions.h device.h device_cache.h FreeRTOSConfig.h interrupts.h toolchain_specifics.h user.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/bsp
    ../src/config/sam_a5d2_xult_freertos_iar/bsp/: bsp.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/driver
    ../src/config/sam_a5d2_xult_freertos_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/driver/usart
    ../src/config/sam_a5d2_xult_freertos_iar/driver/usart/: drv_usart.h drv_usart_definitions.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/osal
    ../src/config/sam_a5d2_xult_freertos_iar/osal/: osal.h osal_definitions.h osal_freertos.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/aic
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/aic/: plib_aic.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/clk
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/clk/: plib_clk.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/flexcom/usart
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/flexcom/usart/: plib_flexcom0_usart.h plib_flexcom_usart_local.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/l2cc
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/l2cc/: plib_l2cc.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/matrix
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/matrix/: plib_matrix.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/mmu
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/mmu/: plib_mmu.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/pio
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/pio/: plib_pio.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/pit
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/pit/: plib_pit.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/uart
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/uart/: plib_uart1.h plib_uart_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/peripheral/xdmac
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/xdmac/: plib_xdmac0.h plib_xdmac_common.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/system
    ../src/config/sam_a5d2_xult_freertos_iar/system/: system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/system/cache
    ../src/config/sam_a5d2_xult_freertos_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/system/debug
    ../src/config/sam_a5d2_xult_freertos_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/system/dma
    ../src/config/sam_a5d2_xult_freertos_iar/system/dma/: sys_dma.h sys_dma_mapping.h
  group Harmony3/Header Files/config/sam_a5d2_xult_freertos_iar/system/int
    ../src/config/sam_a5d2_xult_freertos_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/FreeRTOS/Source/include
    ../src/third_party/rtos/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group Harmony3/Header Files/FreeRTOS/Source/portable/IAR/SAM/CA5
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: portASM.h portmacro.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP
    ../src/packs/ATSAMA5D27_DFP/: sama5d27.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/component
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/instance
    ../src/packs/ATSAMA5D27_DFP/instance/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom0.h flexcom1.h flexcom2.h flexcom3.h flexcom4.h gmac.h i2sc0.h i2sc1.h icm.h isc.h l2cc.h lcdc.h matrix0.h matrix1.h mcan0.h mcan1.h mpddrc.h pdmic.h pio.h pit.h pmc.h ptc.h pwm.h qspi0.h qspi1.h rstc.h rtc.h rxlp.h saic.h sckc.h sdmmc0.h sdmmc1.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi0.h spi1.h ssc0.h ssc1.h tc0.h tc1.h tdes.h trng.h twihs0.h twihs1.h uart0.h uart1.h uart2.h uart3.h uart4.h udphs.h wdt.h xdmac0.h xdmac1.h
  group Harmony3/Header Files/packs/ATSAMA5D27_DFP/pio
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core_A/Include
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
  group Harmony3/Linker File
    ../src/config/sam_a5d2_xult_freertos_iar/: ddr.icf
  group Harmony3/Source Files
    ../src/: app_usart_usb_click_board.c app_usart_usb_debug_port.c main.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar
    ../src/config/sam_a5d2_xult_freertos_iar/: cstartup.s fault_handlers.c freertos_hooks.c initialization.c interrupts.c tasks.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/bsp
    ../src/config/sam_a5d2_xult_freertos_iar/bsp/: bsp.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/driver/usart
    ../src/config/sam_a5d2_xult_freertos_iar/driver/usart/src/: drv_usart.c drv_usart_local.h
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/osal
    ../src/config/sam_a5d2_xult_freertos_iar/osal/: osal_freertos.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/aic
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/aic/: plib_aic.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/clk
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/clk/: plib_clk.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/flexcom/usart
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/flexcom/usart/: plib_flexcom0_usart.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/l2cc
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/l2cc/: plib_l2cc.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/matrix
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/matrix/: plib_matrix.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/mmu
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/mmu/: plib_mmu.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/pio
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/pio/: plib_pio.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/pit
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/pit/: plib_pit.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/uart
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/uart/: plib_uart1.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/peripheral/xdmac
    ../src/config/sam_a5d2_xult_freertos_iar/peripheral/xdmac/: plib_xdmac0.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/stdio
    ../src/config/sam_a5d2_xult_freertos_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/system/cache
    ../src/config/sam_a5d2_xult_freertos_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/system/dma
    ../src/config/sam_a5d2_xult_freertos_iar/system/dma/: sys_dma.c
  group Harmony3/Source Files/config/sam_a5d2_xult_freertos_iar/system/int
    ../src/config/sam_a5d2_xult_freertos_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/FreeRTOS/Source
    ../src/third_party/rtos/FreeRTOS/Source/: croutine.c event_groups.c FreeRTOS_tasks.c list.c queue.c stream_buffer.c timers.c
  group Harmony3/Source Files/FreeRTOS/Source/portable/IAR/SAM/CA5
    ../src/third_party/rtos/FreeRTOS/Source/portable/IAR/SAM/CA5/: FreeRTOS_tick_config.c port.c portASM.s
  group Harmony3/Source Files/FreeRTOS/Source/portable/MemMang
    ../src/third_party/rtos/FreeRTOS/Source/portable/MemMang/: heap_1.c
